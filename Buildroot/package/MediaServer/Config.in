## Buildroot/package/MediaServer/Config.in
```kconfig
config BR2_PACKAGE_MEDIASERVER
	bool "MediaServer"
	help
	  Media Server App using QT5
```
